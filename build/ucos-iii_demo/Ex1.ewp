# IAR project Ex1.ewp, settings and files
configuration Debug (ARM, debug)
  ICCARM.CCIncludePath2: ..\..\src\projects\fire_ucos_led_demo; ..\..\src\common; ..\..\src\cpu; ..\..\src\cpu\headers; ..\..\src\platforms; ..\..\src\drivers; ..\..\src\drivers\adc; ..\..\src\drivers\AT24C02; ..\..\src\drivers\exti; ..\..\src\drivers\delay; ..\..\src\drivers\FTM; ..\..\src\drivers\gpio; ..\..\src\drivers\i2c; ..\..\src\drivers\LED; ..\..\src\drivers\lptmr; ..\..\src\drivers\mcg; ..\..\src\drivers\PIT; ..\..\src\drivers\pmc; ..\..\src\drivers\rtc; ..\..\src\drivers\uart; ..\..\src\drivers\wdog; ..\..\build; ..\..\src\uCOS-II\Ports; ..\..\src\uCOS-II\Source; ..\..\src\uCOS-II\App; ..\..\src\uCOS-II\App\CFG; ..\..\src\HWdrivers\Nokia5110_LCD\inc; ..\..\src\HWdrivers\LED
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Ex1.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group common
    ../../src/common/: alloc.c assert.c io.c memtest.c printf.c queue.c startup.c stdlib.c uif.c
  group cpu
    ../../src/cpu/: arm_cm4.c crt0.s start.c sysinit.c vectors.c
  group drivers
    ../../src/drivers/adc/: adc.c dac.c delay.c exti.c FTM.c gpio.c LED.C lptmr.c mcg.c pmc.c rtc.c uart.c wdog.c
  group header
    ../../src/common/: common.h
  group HWDrivers
    ../../src/HWdrivers/LED/: LED_CORE.c
    ../../src/HWdrivers/Nokia5110_LCD/src/: nokia_5110.c
